#
# Copyright (C) 2008 OpenedHand Ltd.
#
require omap-image-minimal.bb

IMAGE_INSTALL += "mtd-utils"
