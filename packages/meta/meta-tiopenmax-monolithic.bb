DESCRIPTION = "Texas Instruments OpenMAX IL."
PR = "r1"
PROVIDES = "virtual/openmax-il"
RPROVIDES = "virtual/openmax-il"

DEPENDS = "tiopenmax"
